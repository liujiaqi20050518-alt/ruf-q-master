# Keil uVision project RUF_100.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RUF_100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE STDPERIPH DRIVER,GD32F30X HD
  c include: .\Lib\CMSIS;.\Lib\CMSIS\GD\GD32F30x\Include;.\Lib\CMSIS\GD\GD32F30x\Source\ARM;.\Lib\GD32F30x_standard_peripheral\Include;.\Core;.\Code;.\Task\inc;.\Middlerwares\FreeRTOS;.\Middlerwares\FreeRTOS\inc;.\Middlerwares\FreeRTOS\port\RVDS\ARM_CM4F;.\Middlerwares\SEGGER_RTT;.\Middlerwares\EasyLogger\inc;.\BSP\ST7789;.\BSP;.\Middlerwares\LVGL\lvgl;.\Middlerwares\LVGL\lvgl\src;.\Middlerwares\LVGL\lvgl\examples\porting;.\Middlerwares\LVGL\lvgl\demos\widgets;.\Middlerwares\LVGL;.\BSP\KEY\inc;.\App\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Core
    ./Core/: main.c gd32f30x_it.c systick.c dma.c spi.c gpio.c ruc.c
  group App
    ./App/Src/: menu.c menu_callbacks.c parameter_editor.c
  group Lib
    ./Lib/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group startup
    ./Lib/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ./Lib/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group BSP
    ./BSP/ST7789/: bsp_st7789_driver.c fonts.c
    ./BSP/KEY/src/: bsp_key.c
  group Task
    ./Task/src/: task_start.c task_test.c task_display.c bsp_tasks_manager.c
  group Middlewares/FreeRTOS/Src
    ./Middlerwares/FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/Port
    ./Middlerwares/FreeRTOS/port/MemMang/: heap_4.c
    ./Middlerwares/FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Middlewares/RTT
    ./Middlerwares/SEGGER_RTT/: SEGGER_RTT_Conf.h SEGGER_RTT_printf.c SEGGER_RTT.c
  group Middlewares/Easylogger
    ./Middlerwares/EasyLogger/port/: elog_port.c
    ./Middlerwares/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
